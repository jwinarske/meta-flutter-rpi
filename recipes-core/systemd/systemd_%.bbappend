PACKAGECONFIG:remove = "networkd resolved"